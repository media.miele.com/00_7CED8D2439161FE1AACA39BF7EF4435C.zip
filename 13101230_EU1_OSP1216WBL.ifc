Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b2d1b807-14bb-452f-b9e2-858d1d64b6f9, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-02T07:23:16+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13101230_EU1_OSP1216WBL:331B1PSW_EU1_13101230_OSP1216WBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW, z_Miele_Design_CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 331B1PSW_EU1_13101230_OSP1216WBL; sets with these values: 2
